## Kconfig
```kconfig
config RTL8852CU
	tristate "Realtek 8852C USB WiFi"
	depends on USB
	help
	  Help message of RTL8852CU
```
